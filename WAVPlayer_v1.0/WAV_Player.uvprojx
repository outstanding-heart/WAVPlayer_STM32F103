# Keil uVision project WAV_Player.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: WAV_Player
  c flags: Optim=1 wLevel=2
  c include: .\RTE\Include;.\RTE;.\RTE\Device\STM32F103ZE;..\1-5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c usart1.c dac.c flash.c sd.c wavsd.c fatfs.c key.c irqserver.c
  group EVAL
    ./USER/: stm3210e_eval.c stm3210e_eval_sdio_sd.c
  group FF
    ./USER/: ff.c diskio.c syscall.c cc936.c
  group ::CMSIS
    C:/Users/hejue/Desktop/Work/MDK5.11/ARM/PACK/ARM/CMSIS/4.1.0/CMSIS_RTX/LIB/ARM/: RTX_CM3.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    C:/Users/hejue/Desktop/Work/MDK5.11/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
